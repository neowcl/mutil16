# Keil uVision project gauge.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\version5.6)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gauge +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\CMSIS\STM32;..\startup\STM32;..\FWLIB\Include\STM32;..\mcu drive;..\mcu drive\gpio_init;..\mcu drive\stdio_mcu_drive;..\mcu drive\spi_drive;..\mcu drive\interrupt;..\mcu drive\systick;..\mcu drive\usart_drive;..\mcu drive\TIMER_DRIVE;..\mcu drive\system clock configuration;..\interface;..\interface\sysclockfuzhi;..\application;..\application\chushihua;..\mcu drive\can_drive;..\soft;..\interface\TIMER_interface;..\interface;..\peripheral drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group application
    ../application/: flash.c main.c stm32f10x_it.c RS485_exchange.c Can_Exchange.c
    ../application/chushihua/: chushihua.c
  group interface
    ../interface/: GPIO_Par_Inter.c TIMER_interface.c can_interface.c ALarm_EXit_inter.c Usart_interface.c Schedule.c Low_power_inter.c
  group peripheral drive
    ../peripheral drive/: Bq7695202_drive.c
  group mcu drive
    ../mcu drive/systick/: systick.c
    ../mcu drive/: IIC_Hard_Drive.c
    ../mcu drive/gpio_init/: gpio_init.c
  group startup
    ../startup/STM32/: startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/Source/STM32/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/STM32/: system_stm32f10x.c core_cm3.c
